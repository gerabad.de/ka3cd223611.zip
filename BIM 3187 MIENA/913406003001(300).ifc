Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_3/temp/tmp_1836_326_R3fXX/format_0/913406003001(300).ifc
Time: 2023-10-11T08:12:41
Made in: PARTsolutions

# IfcProject, 913406003001(300)
Description: MING Wash bowl 3187

# IfcDiscreteAccessory, 913406003001(300)
In: BUILDING
Description: 913406003001(300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 913406003001
ePset_PARTsolutions - NB: 913406003001(300); NN: 3187; NT: MING Wash bowl 3187; NBSYN: $A.($LODLEVEL.); LINA: 913406003001(300); CATALOG: Kaldewei; A: 913406003001; LODLEVEL: 300; B: kaldewei_3187_ming_mit_grauen_linien.png; C: MING Wash bowl 3187; D: 5.6; E: KALDEWEI; F: 4055761218153; M: Furnishing Element; N: IfcSanitaryTerminalType; O: SS-35-65-70-94; P: Wash Basin Systems; Q: 23-31-13-11; R: RVT_METRICPLUMBINGFIXTURE; S: EC011550; EF002169: enamelled steel (EV000166); EF000139: Enamelled (EV002029); EF000051: round Bowl (EV000167); EF000007: alpine white (EV000202); EF000003: post top (EV003651); EF000049: 400; EF004567: 400
